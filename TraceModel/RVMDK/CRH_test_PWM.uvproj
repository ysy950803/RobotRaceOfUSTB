# Keil uVision project CRH_test_PWM.uvproj, settings and files
target CRH_test_pwm (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CRH_test_PWM +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../src/: main.c TIM4.c Motor_TIM4.c Follow.c
  group Hal
    ../src/: GPIO.c hal.c RCC.c stm32f10x_it.c NVIC.c
  group FWLib
    ../src/STM32Lib/: stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c core_cm3.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c
  group StartUp
    ../src/STM32Lib/StartUp/: startup_stm32f10x_md.s
  group DOC
    ../: Doc.txt
