# Keil uVision project XiaoNeiSai.uvprojx, settings and files
target xiaoneisai (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: XiaoNeiSai +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\CMSIS;.\Libraries\inc;.\Drivers;.\Libraries\src;.\Output;.\Startup;.\User
  asm include: .\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group CMSIS
    ./CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Libraries
    ./Libraries/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_flash.c
    ./Libraries/inc/: misc.h stm32f10x_rcc.h stm32f10x_gpio.h stm32f10x_dma.h stm32f10x_usart.h stm32f10x_adc.h stm32f10x_tim.h stm32f10x_flash.h
  group Drivers
    ./Drivers/: Delay.c Delay.h Encoder.c Encoder.h IOinput.c IOinput.h IOoutput.c IOoutput.h Motor.c Motor.h Sensor.c Sensor.h Servo.c Servo.h Usart.c Usart.h Zlg7290.c Zlg7290.h Pid.c Pid.h
  group User
    ./User/: main.c main.h Config.h Global.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
